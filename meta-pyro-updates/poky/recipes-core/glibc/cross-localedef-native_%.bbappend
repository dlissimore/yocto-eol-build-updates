
CFLAGS += "-D_IO_fwide=fwide"

