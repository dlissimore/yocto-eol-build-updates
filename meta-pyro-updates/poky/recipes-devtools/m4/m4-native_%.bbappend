FILESEXTRAPATHS_append := ":${THISDIR}/m4"
SRC_URI += "\
        file://m4-1.4.18-glibc-change-work-around.patch \
"


